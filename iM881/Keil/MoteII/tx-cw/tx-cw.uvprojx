# Keil uVision project tx-cw.uvprojx, settings and files
target tx-cw-868 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L051C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: tx-cw +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L051xx USE_BAND_868 HAL_USART_MODULE_ENABLED
  c include: ..\..\..\src;..\..\..\src\boards\MoteII;..\..\..\src\boards\MoteII\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto;..\tx-cw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group apps
    ./: main.c
  group boards\MoteII
    ../../../src/boards/MoteII/: adc-board.c board.c gpio-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c uart-board.c gps-board.c
    ./: ic_Swich.c
  group boards\MoteII\cmsis
    ../../../src/boards/MoteII/cmsis/arm-std/: startup_stm32l051xx.s
    ../../../src/boards/MoteII/cmsis/: system_stm32l0xx.c
  group boards\MoteII\STM32L0xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group peripherals
    ../../../src/peripherals/: gpio-ioe.c
  group radio
    ../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
target tx-cw-915 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L051C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: as above
  output: tx-cw +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L051xx USE_BAND_915
  c include: ..\..\..\src;..\..\..\src\boards\MoteII;..\..\..\src\boards\MoteII\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\peripherals\ble;..\..\..\src\peripherals\display;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
